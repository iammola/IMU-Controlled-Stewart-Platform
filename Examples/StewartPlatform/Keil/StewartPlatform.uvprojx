# Keil uVision project StewartPlatform.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: StewartPlatform
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\..\Library;..\..\..\..\Development
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ../: Main.c
    ../../../Library/FPU/: fpu.c
    ../../../Library/PLL/: PLL.c
    ../../../Library/IMU/: IMU.c
    ../../../Library/Joystick/: Joystick.c
    ../../../Library/Pololu Maestro/: Maestro.c
    ../../../Library/StewartPlatform/: StewartPlatform.c
    ../../../Library/IMU/ICM-20948/: ICM-20948.c
    ../../../Library/IMU/ICM-20948/Fusion/: FusionAhrs.c FusionCompass.c FusionOffset.c
    ../../../Library/UART/: UART4.c
    ../../../Library/Quaternion/: Quaternion.c
    ../../../Library/SSI/: SSI2.c
    ../../../Library/SysTick/: SysTick.c
    ../../../Library/CLI/: CLI.c
software components: CMSIS:CORE 6.0.0, Device:Startup 1.0.1

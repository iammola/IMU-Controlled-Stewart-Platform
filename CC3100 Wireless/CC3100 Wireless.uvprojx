# Keil uVision project CC3100 Wireless.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CC3100 Wireless
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: PART_TM4C123GH6PM TARGET_IS_BLIZZARD_RA1
  c include: .\CC3100_P2P\simplelink\inc;.\CC3100_P2P\simplelink\driverlib
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Main
    ./: P2P_main.c
    ./CC3100_P2P/: P2P.c
  group SDK DriverLib
    ./CC3100_P2P/simplelink/driverlib/: gpio.c systick.c uart.c
  group SDK SimpleLink
    ./CC3100_P2P/simplelink/: board.c cli_uart.c device.c driver.c flowcont.c fs.c netapp.c netcfg.c nonos.c socket.c spawn.c spi.c uart.c wlan.c timer_tick.c
software components: CMSIS:CORE 6.0.0, Device:Startup 1.0.1
